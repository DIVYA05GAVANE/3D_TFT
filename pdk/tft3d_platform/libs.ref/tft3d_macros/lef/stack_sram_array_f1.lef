VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS
MACRO stack_sram_array_f1
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  FOREIGN stack_sram_array_f1 0 0 ;
  SIZE 2900.000 BY 3000.000 ;
  SYMMETRY X Y ;
  OBS
    LAYER SD ;
      RECT 0 0 2900.000 3000.000 ;
    LAYER GATE ;
      RECT 0 0 2900.000 3000.000 ;
    LAYER MT1 ;
      RECT 0 0 2900.000 3000.000 ;
    LAYER MT2 ;
      RECT 0 0 2900.000 3000.000 ;
  END
END stack_sram_array_f1
END LIBRARY
