# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
L3_0 = (3, 0)
L8_0 = (8, 0)
L8_1 = (8, 1)
L9_0 = (9, 0)
L10_0 = (10, 0)
L10_1 = (10, 1)
L150_5 = (150, 5)

pcont_cdns_782127390580 = lib.new_cell('pcont_CDNS_782127390580')

m2_m1_cdns_782127390580 = lib.new_cell('M2_M1_CDNS_782127390580')
R(m2_m1_cdns_782127390580, L8_0, [(-5,-5.035,5,5.035)])
R(m2_m1_cdns_782127390580, L9_0, [(-5,-5,5,5)])
R(m2_m1_cdns_782127390580, L10_0, [(-5,-5.035,5,5.035)])

nfet_w6u_l5 = lib.new_cell('nfet_W6u_L5')
R(nfet_w6u_l5, L3_0, [(7.242,19.213,23.242,37.238)])
R(nfet_w6u_l5, L8_0, [(10.03,0.31,20.082,6.16), (13.978,4.135,16.477,6.635), (13.695,51.745,16.195,54.245), (10.03,53.308,20.082,59.157)])
P(nfet_w6u_l5, L8_0, [(7.092,4.248),(7.092,19.275),(9.5,19.275),(9.5,39.218),(7.092,39.218),(7.092,54.245),(23.093,54.245),(23.093,39.218),(20.5,39.218),(20.5,19.275),(23.093,19.275),(23.093,4.248)])
R(nfet_w6u_l5, L10_0, [(0.28,23.387,3.85,33.373), (26.327,23.387,29.897,33.373), (2.698,25.235,12.697,31.235), (17.722,25.235,27.722,31.235), (25.227,26.86,27.727,29.36), (2.712,26.878,5.213,29.377)])
nfet_w6u_l5.add(gdstk.Reference(pcont_cdns_782127390580, (2.033,39.985)))
nfet_w6u_l5.add(gdstk.Reference(m2_m1_cdns_782127390580, (15.12,45.795)))
nfet_w6u_l5.add(gdstk.Reference(m2_m1_cdns_782127390580, (15.12,12.68)))
nfet_w6u_l5.add(gdstk.Label('G', (15.167,1.107), layer=8, texttype=0))
nfet_w6u_l5.add(gdstk.Label('G', (15.035,58.415), layer=8, texttype=0))
nfet_w6u_l5.add(gdstk.Label('S', (0.682,27.952), layer=10, texttype=0))
nfet_w6u_l5.add(gdstk.Label('D', (28.873,28.215), layer=10, texttype=0))

pch_pr_nfet_w6u_l5_l = lib.new_cell('pch_pr_nfet_W6u_L5_L')
A(pch_pr_nfet_w6u_l5_l, L8_0, 102, 2, 12, 28, 3, 1, 22, 0)
R(pch_pr_nfet_w6u_l5_l, L8_0, [(32.168,13.108,56,25.108), (32.168,13.108,56,25.108), (50,19.108,62,70), (50,19.108,62,70), (50,48,62,67.755), (18.948,61.755,56,73.755), (49,63,63,77), (56,64,64,76), (50,70,62,76.415), (50,70,62,76.415), (32.035,70.415,56,82.415), (32.035,70.415,56,82.415)])
R(pch_pr_nfet_w6u_l5_l, L10_0, [(49,19,63,33), (56,20,64,32), (50,26,62,46.215), (17.683,39.952,56,51.952), (45.873,40.215,56,52.215), (49,41,63,55), (56,42,64,54), (50,45.952,62,48)])
R(pch_pr_nfet_w6u_l5_l, L150_5, [(0,0,64,96)])
pch_pr_nfet_w6u_l5_l.add(gdstk.Reference(nfet_w6u_l5, (17,18)))
pch_pr_nfet_w6u_l5_l.add(gdstk.Label('D', (64,26), layer=10, texttype=1))
pch_pr_nfet_w6u_l5_l.add(gdstk.Label('S', (64,48), layer=10, texttype=1))
pch_pr_nfet_w6u_l5_l.add(gdstk.Label('G', (64,70), layer=8, texttype=1))

pch_pr_nfet_w6u_l5_r = lib.new_cell('pch_pr_nfet_W6u_L5_R')
A(pch_pr_nfet_w6u_l5_r, L8_0, 102, 2, 12, 28, 3, 1, 22, 0)
R(pch_pr_nfet_w6u_l5_r, L8_0, [(8,13.108,32.168,25.108), (8,13.108,32.168,25.108), (2,19.108,14,70), (2,19.108,14,70), (2,48,14,67.755), (8,61.755,18.948,73.755), (1,63,15,77), (0,64,8,76), (2,70,14,76.415), (2,70,14,76.415), (8,70.415,32.035,82.415), (8,70.415,32.035,82.415)])
R(pch_pr_nfet_w6u_l5_r, L10_0, [(1,19,15,33), (0,20,8,32), (2,26,14,46.215), (8,39.952,17.683,51.952), (8,40.215,45.873,52.215), (1,41,15,55), (0,42,8,54), (2,45.952,14,48)])
R(pch_pr_nfet_w6u_l5_r, L150_5, [(0,0,64,96)])
pch_pr_nfet_w6u_l5_r.add(gdstk.Reference(nfet_w6u_l5, (17,18)))
pch_pr_nfet_w6u_l5_r.add(gdstk.Label('D', (0,26), layer=10, texttype=1))
pch_pr_nfet_w6u_l5_r.add(gdstk.Label('S', (0,48), layer=10, texttype=1))
pch_pr_nfet_w6u_l5_r.add(gdstk.Label('G', (0,70), layer=8, texttype=1))

precharge_equalizer_nmos = lib.new_cell('precharge_equalizer_nmos_6u')
R(precharge_equalizer_nmos, L8_0, [(146,10,158,22), (194,10,206,22), (224,10,236,22), (146,16,158,132), (194,16,206,400), (224,16,236,534), (96,126,164,138), (96,260,206,272), (98,350,110,390), (96,394,206,406), (152,470,164,505), (98,500,110,525), (96,528,236,540)])
R(precharge_equalizer_nmos, L8_1, [(146,10,158,22), (194,10,206,22), (224,10,236,22)])
R(precharge_equalizer_nmos, L9_0, [(98,347,110,353), (98,387,110,393), (152,467,164,473), (98,497,110,503), (152,502,164,508), (98,522,110,528)])
R(precharge_equalizer_nmos, L10_0, [(216,10,228,22), (216,16,228,88), (96,82,222,94), (60,104,164,116), (54,110,66,356), (60,216,164,228), (96,238,164,250), (98,244,110,350), (60,350,164,362), (96,372,164,384), (152,378,164,470), (98,390,110,500), (96,484,164,496), (152,505,164,604), (96,506,164,518), (98,525,110,604), (90,590,118,618), (144,590,172,618)])
R(precharge_equalizer_nmos, L10_1, [(216,10,228,22)])
R(precharge_equalizer_nmos, L150_5, [(0,0,260,620)])
precharge_equalizer_nmos.add(gdstk.Reference(pch_pr_nfet_w6u_l5_l, (32,62)))
precharge_equalizer_nmos.add(gdstk.Reference(pch_pr_nfet_w6u_l5_r, (164,62)))
precharge_equalizer_nmos.add(gdstk.Reference(pch_pr_nfet_w6u_l5_l, (32,196)))
precharge_equalizer_nmos.add(gdstk.Reference(pch_pr_nfet_w6u_l5_r, (164,196)))
precharge_equalizer_nmos.add(gdstk.Reference(pch_pr_nfet_w6u_l5_l, (32,330)))
precharge_equalizer_nmos.add(gdstk.Reference(pch_pr_nfet_w6u_l5_r, (164,330)))
precharge_equalizer_nmos.add(gdstk.Reference(pch_pr_nfet_w6u_l5_l, (32,464)))
precharge_equalizer_nmos.add(gdstk.Reference(pch_pr_nfet_w6u_l5_r, (164,464)))
precharge_equalizer_nmos.add(gdstk.Label('vpre', (152,16), layer=8, texttype=1))
precharge_equalizer_nmos.add(gdstk.Label('pchg', (200,16), layer=8, texttype=1))
precharge_equalizer_nmos.add(gdstk.Label('eq', (230,16), layer=8, texttype=1))
precharge_equalizer_nmos.add(gdstk.Label('vdd', (222,16), layer=10, texttype=1))
precharge_equalizer_nmos.add(gdstk.Label('bl', (104,604), layer=10, texttype=1))
precharge_equalizer_nmos.add(gdstk.Label('bl', (104,618), layer=10, texttype=1))
precharge_equalizer_nmos.add(gdstk.Label('blb', (158,604), layer=10, texttype=1))
precharge_equalizer_nmos.add(gdstk.Label('blb', (158,618), layer=10, texttype=1))

c_precharge_equalizer_nmos = lib.new_cell('precharge_equalizer_nmos_6u_pitch260')
A(c_precharge_equalizer_nmos, L8_0, 102, 2, 12, 28, 3, 1, 22, 0)
c_precharge_equalizer_nmos.add(gdstk.Reference(precharge_equalizer_nmos, (0,0)))

lib.write_gds('precharge_equalizer_nmos_6u_pitch260.gds')
